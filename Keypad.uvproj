# Keil uVision project Keypad.uvproj, settings and files
target Target (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: Keypad +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c
  group Header
    ./: keyDef.h STC15.h util.h
